# IAR project ADuCM360_demo_blink.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\vlupei\aducm360_test_all\ADuCM360_demo_blink\include; C:\Users\vlupei\aducm360_test_all\ADuCM360_demo_blink\system\include\ADuCM360; C:\Program Files (x86)\IAR Systems\Embedded Workbench 7.3\arm\inc\AnalogDevices; C:\Users\vlupei\aducm360_test_all\ADuCM360_demo_blink\system\include; C:\Users\vlupei\aducm360_test_all\ADuCM360_demo_blink\system\include\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADuCM360_demo_blink.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    src/: blink.c main.c Timer.c
  group startup
    IAR/: startup_ADuCM360.s
  group system
    system/src/ADuCM360/: ClkLib.c DioLib.c GptLib.c WdtLib.c
    system/src/CMSIS/: system_ADuCM360.c
    system/src/diag/: Trace.c
