# Keil uVision project ADuCM360_demo_blink.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.2
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADuCM360_demo_blink
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\include;.\system\include\ADuCM360;.\system\include;.\system\include\CMSIS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./src/: blink.c main.c Timer.c
software components: CMSIS:CORE 5.0.2, Device:Drivers:CLK 1.0.2, Device:Drivers:DIO 1.0.2, Device:Drivers:GPT 1.0.2, Device:Startup 1.0.0
