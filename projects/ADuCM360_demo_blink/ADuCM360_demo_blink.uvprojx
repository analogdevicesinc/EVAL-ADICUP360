# Keil uVision project ADuCM360_demo_blink.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: ADuCM360 Analog Devices
  pack: AnalogDevices.ADuCM36x_DFP.1.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADuCM360_demo_blink
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\include;.\system\include\ADuCM360;.\system\include;.\system\include\CMSIS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src
    ./src/: blink.c main.c Timer.c
  group system
    ./system/src/ADuCM360/: ClkLib.c DioLib.c GptLib.c WdtLib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
